# Keil uVision project Simple-Oscilloscope.uvprojx, settings and files
target Simple-Oscilloscope (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Simple-Oscilloscope +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware/ADC;../Hardware/DMA;../Hardware/FREQ;../Hardware/KEY;../Hardware/LED;../Hardware/TFT;../Hardware/TIMER;../SYSTEM/delay
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Hardware/ADC
    ../Hardware/ADC/: adc.c
  group Hardware/DMA
    ../Hardware/DMA/: dma.c
  group Hardware/FREQ
    ../Hardware/FREQ/: freq.c
  group Hardware/KEY
    ../Hardware/KEY/: key.c
  group Hardware/LED
    ../Hardware/LED/: led.c
  group Hardware/TFT
    ../Hardware/TFT/: tft.c tft_init.c
  group Hardware/TIMER
    ../Hardware/TIMER/: timer.c
  group SYSTEM/delay
    ../SYSTEM/delay/: delay.c
software components: CMSIS:CORE 4.3.0
